# Keil uVision project Compound_Dev.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: Compound_Dev +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: Compound.C main.c README.TXT
    ./Public/: DEBUG.C GPIO.C
